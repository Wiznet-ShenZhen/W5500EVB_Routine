# Keil uVision project W5500EVB_App.uvproj, settings and files
target W5500EVB (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: W5500EVB_App +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output *.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\User\Application;..\User\Driver;..\STM32XX_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32XX_Driver
    ../STM32XX_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group System
    ../System/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Application
    ../User/Application/: main.c stm32f10x_it.c
  group Driver
    ../User/Driver/: auto_update.c bsp_i2c_ee.c bsp_i2c_gpio.c bsp_led.c bsp_spi_flash.c bsp_TiMbase.c bsp_usart1.c dhcp.c fw_updata.c nvic.c socket.c udp_config.c utility.c w5500.c w5500_conf.c
