# Keil uVision project W5500EVB_Init.uvprojx, settings and files
target W5500EVB (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: W5500EVB_Init +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output *.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32XX_Driver\inc;..\System;..\User\Driver;..\User\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STM32XX_Driver
    ../STM32XX_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group System
    ../System/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Application
    ../User/Application/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Driver
    ../User/Driver/: bsp_i2c_ee.c bsp_i2c_gpio.c bsp_led.c bsp_spi_flash.c bsp_TiMbase.c bsp_usart1.c dhcp.c dns.c http_server.c httputil.c netbios.c socket.c utility.c w5500.c w5500_conf.c
